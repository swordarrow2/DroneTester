# Keil uVision project drone_tester.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: drone_tester_420000 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c system_config.c system_uart.c encode.c pwm.c
    ./page/: servo_test.c main_page.c encoder_test.c
  group New Group
    ./lcd/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h
